# Repository k-ying/ESP32C3_Watch

File README.md:

# ESP32C3Watch
## 1. Brief/简介
The smartwatch made based on ESP32-C3(RISC-V MCU), which has heart rate, oximetry, temperature, fall detection and IOT Function. 

> 基于 ESP32-C3的智能手表（RISC-V MCU），具有心率、血氧饱和度、温度、跌倒检测和物联网功能。

The project stems from My Graduation Project in 2022, Since the time for secrecy has ended, I can open source its design and code.The project may be very old, some components and functions can not be used directly, need to be adjusted according to the latest library, please be aware of.

> 该项目源于2022年的毕业设计，因为已满足时间，所以开源其设计与代码。该项目可能比较旧了，有些组件和函数不能直接使用，需要根据最新的库进行调整，请悉知。

Here are the folder descriptions:
1. HardWare: used to store hardware related, circuit design and PCB design, using KiCAD for the design of the project; also contains 3D models and peripherals DataSheet.
2. Software: used to store the programme code of CMU master control, this project uses ESP-IDF (LVGL library) of VScode environment to build the project, the version may be very old.
3. Article: thesis and reference materials.
4. images: README.md needed images.

> 以下是文件夹说明：
> 1. HardWare：用于存放硬件相关，电路设计及PCB设计，使用KiCAD进行设计的工程；还包含3D模型及外设DataSheet。
> 2. Software：用于存放CMU主控的程序代码，该项目使用VScode环境的ESP-IDF(LVGL库)进行工程建立，版本可能很旧了。
> 3. Article：论文及参考资料。
> 4. images：README.md 需要的图片。

## 2. Architecture/架构：

In view of foreign chip design enterprises may take the technology monopoly, coupled with the COVID-19 has made people pay more attention to a healthy life. This topic designed a wearable human health monitoring device based on RISC-V architecture MCU, which can detect the wearer's heart rate, blood oxygen saturation, skin surface temperature, and exercise status in real-time. After scheme comparison, the ESP32-C3 series of Espressif Systems CO., LTD. was selected as the master chip. The MAX30102 sensor was used to obtain photoplethysmogram(PPG) signals, which can calculate heart rate and blood oxygen saturation(SpO2) data. MAX30205 was used to obtain real-time temperature, and MPU-6050 Inertial measurement unit(IMU) was used to obtain motion state data, so as to realize the functions of sedentary and falling reminder.

A GUI interface based on LVGL allows users to interact with the device and view data, ifconnected to a Wi-Fi hotspot, it will upload data to the AliCloud IOT server via MQTT. Through the AliCloud data visualization platform, users can view historical data and fall alarm information by using the supporting APP.

After finishing the design, the device defects were found and optimized through various 
functional tests. Finally, good stability of the device and accuracy of data was realized.

> 鉴于国外芯片设计企业可能采取的技术垄断，加之疫情让人们对健康生活更加重视，本课题设计了一款基于 RISC-V 架构 MCU 的穿戴式人体健康监测装置，可实时检测佩戴者的心率和血氧饱和度、皮肤表面温度以及运动状态等健康参数。经过方案比对，最终选择乐鑫科技的 ESP32-C3 系列作为主控芯片，使用 MAX30102 传感器获取光电容积脉搏波（PPG）并计算心率、血氧饱和度(SpO2)数据，通过 MAX30205 获取实时温度、MPU-6050 惯性测量单元(IMU)获取运动状态数据，从而实现久坐、跌倒提醒等功能。

> 用户可通过基于 LVGL 设计的 GUI 界面进行人机交互、数据查看，还可将装置连接至 Wi-Fi 热点，数据会通过 MQTT 协议上传至阿里云 IOT 服务器。借由阿里数据可视化平台，用户端可使用配套 APP 查看历史数据、跌倒警报信息等。

> 装置设计完成后，通过各项功能测试，发现存在设计缺陷并进行了改正及优化，最终实现了装置的稳定与数据的准确可靠。

## 3. Schematic/原理图

For a detailed description, please see the Article/ESP32C3Watch_CN.pdf

> 详细的介绍请见文件 Article/ESP32C3Watch_CN.pdf

## 4. PCB

The PCB is just used as a reference, it can actually be made better and smaller. For a detailed description, please see the Article/ESP32C3Watch_CN.pdf

> PCB只是作为一个参考，实际上它可以做得更好、更小巧。详细的介绍请见文件 Article/ESP32C3Watch_CN.pdf

## 5. Function/功能

For a detailed description, please see the Article/ESP32C3Watch_CN.pdf

> 详细的介绍请见文件 Article/ESP32C3Watch_CN.pdf

## 6. Display results/结果展示

For a detailed description, please see the Article/ESP32C3Watch_CN.pdf

> 详细的介绍请见文件 Article/ESP32C3Watch_CN.pdf

## KiCad design Hardware/ESP32C3Watch_VER2/ESP32C3Watch_VER2.kicad_pcb

Parts:
C1, C3, C8, C9, C11, C13, C14: 0.1uf; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
C2, C4, C10, C12: 10uf; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
C5, C6, C7: 1uf; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
D1: TVS_SMAJ5; D_SMA_Handsoldering
D2: CHG; LED_0603_1608Metric_Pad1.05x0.95mm_HandSolder
D3: STD; LED_0603_1608Metric_Pad1.05x0.95mm_HandSolder
D4: PWR; LED_0603_1608Metric_Pad1.05x0.95mm_HandSolder
J1: Conn_01x02; PinHeader_1x02_P2.54mm_Vertical
J2: USB_B_Micro; USB_Micro-B_Molex-105017-0001
J3: MAX30102_Module; PinHeader_1x07_P2.54mm_Vertical
J4: Conn_01x01; PinHeader_1x01_P1.00mm_Vertical
J5: Conn_01x01; PinHeader_1x01_P2.54mm_Vertical
J6: LCD_8Pin; PinHeader_1x08_P2.54mm_Vertical
J7: LCD_CTP; Molex_200528-0040_1x04-1MP_P1.00mm_Horizontal
L1: ESP-C3-13-4M; ESP-C3-13
R1, R2: 1k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R3: 4.7K; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R4, R5, R13, R14, R17, R18, R19: x; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R6: 10k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R7, R22, R23: 0; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R8, R9, R10: 10K; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R15, R16: 4.7k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
SW1: SW_SPDT; SW_CuK_OS102011MA1QN1_SPDT_Angled
U1: TP4056; Diodes_SO-8EP
U2: XC6206-1.8; SOT-23
U3: TC1262-33; SOT-223-3_TabPin2
U4: MAX30102; Maxim_OLGA-14_3.3x5.6mm_P0.8mm
U5: CH340C; SOIC-16_3.9x9.9mm_P1.27mm
U6: MPU-6050; InvenSense_QFN-24_4x4mm_P0.5mm
U7: MAX30205MTA+T; SON65P300X300X80-9N

Connections:
+3V3: C3.1, C4.1, C6.1, C8.1, C9.1, C10.1, C13.1, J3.1, J6.2, L1.1 (3V3), R6.1, R8.1, R9.1, R10.1, R13.2, R14.2, R15.2, R16.2, R17.2, R18.2, U2.3 (VI), U3.3 (VO), U4.9 (VLED+), U4.10 (VLED+), U6.8 (VDDIO), U6.13 (VDD), U7.8 (VDD)
+5V: C1.1, C2.1, D1.2 (A2), J2.1 (VBUS), R1.2, R2.2, U1.4 (VCC), U1.8 (CE), U5.16 (VCC)
/C3REST: C7.1, L1.2 (EN), R8.2
/CH_D+: R22.2, U5.5 (UD+)
/CH_D-: R23.2, U5.6 (UD-)
/GPIO0: J4.1, L1.18 (IO0)
/GPIO1: J5.1, L1.17 (IO1)
/GPIO2: J3.2, J7.4, L1.16 (IO2), R5.1, R13.1, R16.1, R17.1, U4.2 (SCL), U6.23 (SCL), U7.2 (SCL)
/GPIO3: J3.3, J7.3, L1.15 (IO3), R4.1, R14.1, R15.1, R18.1, U4.3 (SDA), U6.24 (SDA), U7.1 (SDA)
/GPIO4: J6.7, L1.3 (IO4)
/GPIO5: J6.5, L1.4 (IO5)
/GPIO6: J6.4, L1.5 (IO6)
/GPIO7: J6.3, L1.6 (IO7)
/GPIO8: L1.7 (IO8), R9.2
/GPIO9: L1.8 (IO9), R10.2, R19.2
/GPIO10: J6.8, L1.10 (IO10)
/MCU_D+: L1.14 (IO19)
/MCU_D-: L1.13 (IO18)
/U0RXD: L1.11 (RXD), U5.2 (TXD)
/U0TXD: L1.12 (TXD), U5.3 (RXD)
/USB_D+: J2.3 (D+), R22.1
/USB_D-: J2.2 (D-), R23.1
/VBAT_3.7: C5.1, SW1.3 (C), U3.1 (VI)
GNDA: C1.2, C2.2, C3.2, C4.2, C5.2, C6.2, C7.2, C8.2, C9.2, C10.2, C13.2, C14.2, D1.1 (A1), D4.1 (K), J1.2, R3.2, R7.1, R19.1, U1.1 (TEMP), U1.3 (GND), U1.9, U2.1 (GND), U3.2 (GND), U4.12 (GND)
GNDD: C11.2, C12.2, J2.5 (GND), J2.6 (Shield), J3.7, J6.1, L1.9 (GND), R7.2, U4.4 (PGND), U5.1 (GND), U6.1 (CLKIN), U6.9 (AD0), U6.11 (FSYNC), U6.18 (GND), U7.4 (GND), U7.5 (A2), U7.6 (A1), U7.7 (A0)
unnamed: C11.1, U6.10 (REGOUT)
unnamed: C12.1, U6.20 (CPOUT)
unnamed: C14.1, U5.4 (V3)
unnamed: D2.1 (K), U1.7 (~CHRG)
unnamed: D2.2 (A), R2.1
unnamed: D3.1 (K), U1.6 (~STDBY)
unnamed: D3.2 (A), R1.1
unnamed: D4.2 (A), R6.2
unnamed: J1.1, SW1.2 (B)
unnamed: R3.1, U1.2 (PROG)
unnamed: R4.2, R5.2, U2.2 (VO), U4.11 (VDD)
unnamed: SW1.1 (A), U1.5 (BAT)

Notes on the sheet:
MAX30205温度传感模块
* IO9、10是连在一起的
屏幕CS
屏幕BL
* MAX30102模块备用口
GPIO9要加按钮
MAX30102心率血氧模块
IIC_SDA
* IIC上拉电阻预留 (若线路太长IIC电平可能拉不高)
8、9 启动模式
屏幕SDA
触控屏幕接口（ST7789V+FT6236G）
MPU6050姿态传感模块
屏幕SCL
接口和供电及ESP32核心
屏幕RES
* JTAG调试口射频 启动后无法使用
* 引出剩余接口备用
* IIC上拉电阻预留 (FPC太长IIC电平可能拉不高)
* IIC上拉电阻预留 1.8V?
* 触摸接口
电池接口
该触摸屏无需DC口
TP4056充放电管理
GPIO8要做上拉
* 串口调试口 使用CH340C
屏幕底板带 * 背光控制三极管
* 数模共地
USB转串口电路CH340C
IIC_SCL

Board: 2 copper layers, 42.0 x 42.0 mm, 53 parts (18 on the bottom side), 35 nets.

File Hardware/ESP32C3Watch_VER2/ESP32C3Watch_VER2_BOM.csv:

"Comment","Description","Designator","Footprint","LibRef","Pins","Quantity","PartNumber","url",
"0.1uf","desc","C1,C3,C8,C9,C13,C14,","C_0603_1608Metric_Pad1.08x0.95mm_HandSolder","libref","2","6","","",
"10uf","desc","C2,C4,C10,","C_0603_1608Metric_Pad1.08x0.95mm_HandSolder","libref","2","3","","",
"1uf","desc","C6,","C_0603_1608Metric_Pad1.08x0.95mm_HandSolder","libref","2","1","","",
"TVS_SMAJ5","desc","D1,","D_SMA_Handsoldering","libref","2","1","","",
"PWR","desc","D4,","LED_0603_1608Metric_Pad1.05x0.95mm_HandSolder","libref","2","1","","",
"LCD_CTP","desc","J7,","Molex_200528-0040_1x04-1MP_P1.00mm_Horizontal","libref","6","1","","",
"4.7K","desc","R3,","R_0603_1608Metric_Pad0.98x0.95mm_HandSolder","libref","2","1","","",
"x","desc","R4,R5,R13,R14,R17,R18,","R_0603_1608Metric_Pad0.98x0.95mm_HandSolder","libref","2","6","","",
"0","desc","R7,","R_0603_1608Metric_Pad0.98x0.95mm_HandSolder","libref","2","1","","",
"10K","desc","R9,R10,","R_0603_1608Metric_Pad0.98x0.95mm_HandSolder","libref","2","2","","",
"4.7k","desc","R15,R16,","R_0603_1608Metric_Pad0.98x0.95mm_HandSolder","libref","2","2","","",
"TP4056","desc","U1,","Diodes_SO-8EP","libref","9","1","","",
"XC6206-1.8","desc","U2,","SOT-23","libref","3","1","","",
"TC1262-33","desc","U3,","SOT-223-3_TabPin2","libref","4","1","","",
"MPU-6050","desc","U6,","InvenSense_QFN-24_4x4mm_P0.5mm","libref","25","1","","",
"1uf","desc","C5,C7,","C_0603_1608Metric_Pad1.08x0.95mm_HandSolder","libref","2","2","","",
"0.1uf","desc","C11,","C_0603_1608Metric_Pad1.08x0.95mm_HandSolder","libref","2","1","","",
"10uf","desc","C12,","C_0603_1608Metric_Pad1.08x0.95mm_HandSolder","libref","2","1","","",
"CHG","desc","D2,","LED_0603_1608Metric_Pad1.05x0.95mm_HandSolder","libref","2","1","","",
"STD","desc","D3,","LED_0603_1608Metric_Pad1.05x0.95mm_HandSolder","libref","2","1","","",
"ESP-C3-13-4M","desc","L1,","ESP-C3-13","libref","18","1","","",
"1k","desc","R1,R2,","R_0603_1608Metric_Pad0.98x0.95mm_HandSolder","libref","2","2","","",
"10k","desc","R6,","R_0603_1608Metric_Pad0.98x0.95mm_HandSolder","libref","2","1","","",
"10K","desc","R8,","R_0603_1608Metric_Pad0.98x0.95mm_HandSolder","libref","2","1","","",
"x","desc","R19,","R_0603_1608Metric_Pad0.98x0.95mm_HandSolder","libref","2","1","","",
"0","desc","R22,R23,","R_0603_1608Metric_Pad0.98x0.95mm_HandSolder","libref","2","2","","",
"MAX30102","desc","U4,","Maxim_OLGA-14_3.3x5.6mm_P0.8mm","libref","14","1","","",
"CH340C","desc","U5,","SOIC-16_3.9x9.9mm_P1.27mm","libref","16","1","","",
"MAX30205MTA+T","desc","U7,","SON65P300X300X80-9N","libref","9","1","","",
"Through Hole Items ",
"","desc",",,","","libref","1","2","","",
"Conn_01x02","desc","J1,","PinHeader_1x02_P2.54mm_Vertical","libref","2","1","","",
"MAX30102_Module","desc","J3,","PinHeader_1x07_P2.54mm_Vertical","libref","7","1","","",
"Conn_01x01","desc","J4,J5,","PinHeader_1x01_P2.54mm_Vertical","libref","1","2","","",
"LCD_8Pin","desc","J6,","PinHeader_1x08_P2.54mm_Vertical","libref","8","1","","",
"SW_SPDT","desc","SW1,","PinHeader_1x03_P2.54mm_Vertical","libref","3","1","","",
"USB_B_Micro","desc","J2,","USB_Micro-B_Molex-105017-0001","libref","13","1","","",

## Commit log

2024-07-04 ReInit Files
